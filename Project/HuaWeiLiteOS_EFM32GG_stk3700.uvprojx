# Keil uVision project HuaWeiLiteOS_EFM32GG_stk3700.uvprojx, settings and files
target EFM32GG_stk3700 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: EFM32GG990F1024 Silicon Labs
  pack: Keil.EFM32GGxxx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HuaWeiLiteOS_EFM32GG_stk3700
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Huawei_LiteOS\kernel\include;..\Huawei_LiteOS\kernel\base\include;..\Huawei_LiteOS\platform\bsp\sample\config;..\Huawei_LiteOS\platform\cpu\arm\cortex-m3;..\User;..\Startup;..\example\include;..\Huawei_LiteOS\kernel\cmsis
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\User\Huawei_LiteOS.sct
  group User
    ../User/: main.c
  group HuaWeiLiteOS_kernel
    ../Huawei_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Huawei_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Huawei_LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../Huawei_LiteOS/kernel/base/misc/: los_misc.c
    ../Huawei_LiteOS/kernel/cmsis/: cmsis_liteos.c
  group HuaWeiLiteOS_platform
    ../Huawei_LiteOS/platform/bsp/sample/config/: los_config.c
    ../Huawei_LiteOS/platform/cpu/arm/cortex-m3/: los_hw.c los_hwi.c los_hw_tick.c los_dispatch.s
  group HuaWeiLiteOS_example
    ../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c
software components: CMSIS:CORE 5.0.1, Board Support:Buttons 4.2.1, Board Support:CORE 4.2.1, Board Support:LED 4.2.1, Device:Startup 4.2.1, Device:emlib:CMU 4.2.1, Device:emlib:EBI 4.2.1, Device:emlib:EMU 4.2.1, Device:emlib:Framework 4.2.1, Device:emlib:GPIO 4.2.1, Device:emlib:INT 4.2.1, Device:emlib:MSC 4.2.1, Device:emlib:SYSTEM 4.2.1, Device:emlib:USART 4.2.1
